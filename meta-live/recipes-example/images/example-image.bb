require  /home/smalinux/repos/yocto/poky/meta/recipes-core/images/core-image-minimal.bb

SUMMARY = "A small image just capable of allowing a device to boot."

LICENSE = "MIT"

IMAGE_INSTALL += "htop"
